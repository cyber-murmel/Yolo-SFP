# Repository cyber-murmel/Yolo-SFP

## KiCad design src/SFP Breakout.kicad_pcb

Parts:
C1, C3: 1u; C_0603_1608Metric
C2, C4: 100n; C_0603_1608Metric
D1: Presence; LED_0603_1608Metric
D2: Signal; LED_0603_1608Metric
D3: Power; LED_0603_1608Metric
J1: SFP; Amphenol SFP
J2, J3, J5, J6: Conn_Coaxial; SMA_Jack_Vertical
J4, J7: Conn_01x02; PinHeader_2x01_P2.54mm_Vertical
J8: Conn_02x02_Counter_Clockwise; PinHeader_2x02_P2.54mm_Vertical
J9: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
J10: USB_B_Micro; USB_Micro-B_Molex-105017-0001
JP1: RD-; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: RD+; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: TD+; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4: TD-; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP5: +3.3V; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2, R3: 1k; R_0603_1608Metric
U1: AZ1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C3.1, C4.1, J1.15, J1.16, JP5.2 (C), R1.1, R2.1, R3.1
+5V: C1.1, C2.1, J10.1 (VBUS), U1.3 (VI)
/3.3Header: J8.1, J8.2, JP5.3 (B)
/3.3USB: JP5.1 (A), U1.2 (VO)
/ID_Clock: J1.5, J9.4
/ID_Data: J1.4, J9.3
/LOS: D2.1 (K), J1.8, J9.7
/RD+: J1.13, J3.1 (In), JP2.2 (B)
/RD-: J1.12, J2.1 (In), JP1.2 (B)
/RD_DP+: J4.1, JP2.1 (A)
/RD_DP-: J4.2, JP1.1 (A)
/RateSelect: J1.7, J9.6
/TD+: J1.18, J5.1 (In), JP3.2 (B)
/TD-: J1.19, J6.1 (In), JP4.2 (B)
/TD_DP+: J7.1, JP3.1 (A)
/TD_DP-: J7.2, JP4.1 (A)
/TxDisable: J1.3, J9.2
/TxFault: J1.2, J9.1
/~Presence: D1.1 (K), J1.6, J9.5
GND: C1.2, C2.2, C3.2, C4.2, D3.1 (K), J1.1, J1.9, J1.10, J1.11, J1.14, J1.17, J1.20, J1.SHIELD, J2.2 (Ext), J3.2 (Ext), J5.2 (Ext), J6.2 (Ext), J8.3, J8.4, J10.5 (GND), J10.6 (Shield), U1.1 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2

Board: 2 copper layers, 68.6 x 27.9 mm, 26 parts (13 on the bottom side), 23 nets.

## Commit log

2018-04-09 Create LICENSE
2018-04-09 added kicad source
